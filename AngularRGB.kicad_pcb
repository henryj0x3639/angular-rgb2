# Repository henryj0x3639/angular-rgb2

File README.md:

# Angular-RGB

### Description

The AngularRGB is a, minimalistic, 40% keyboard that supports perkey RGB Lighting. We've noticed that there are no purchasing options for anyone interested in a rgb per key backlit keyboard, so we decided to create one.
[Website Description!](https://angularmk.xyz/angular-rgb/)

The PCB consists of a 4x12 matrix layed out as a COL to ROW diode configuration with a staggered design. Additionally, there are slots cut out on the board to provide the space for the WS2812B-Mini RGB LEDs that provide the lighting. There are also numerous protection features, such as ESD protections for both the data lines aswell as the power lines; fueses protecting the precious microcontroller in a case of short circuit; and many more.

## KiCad design AngularRGB.kicad_pcb

Parts:
ANT1: SWRA117D; Texas_SWRA117D_2.4GHz_Right
C1, C5, C17, C20: 1u; C_0603_1608Metric
C2, C3: 20pF; C_0603_1608Metric
C4, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C18, C19, C25: 100n; C_0603_1608Metric
C21: 1.5pF; C_0603_1608Metric
C22: 1.0pF; C_0603_1608Metric
C23: 2.2pF; C_0603_1608Metric
C24, C28: 12pF; C_0603_1608Metric
C26: 2.2nF; C_0603_1608Metric
C27: 47n; C_0603_1608Metric
C29: 1.0n; C_0603_1608Metric
C30, C33, C34: 10uF
C31: 1uF
C32: 100n
D1: D; D_SOD-123F
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43: D; D_SOD-123
D44, D45: LED
D46, D47, D48: D_Schottky
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
L1: 3.3nH; L_0603_1608Metric
L2: 4.7nH; L_0603_1608Metric
L3: 10nH; L_0603_1608Metric
L4: 10uH
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED24, LED25, LED26, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46: WS2812; REVERSE_LED
Q1: BSS138; SOT-23
Q2, Q3: 2N7000; TO-92_Inline
R1, R2, R3, R4, R7, R8, R9: 5k1; R_0603_1608Metric
R5, R6: 22; R_0603_1608Metric
R10, R11, R16: 1k
R12, R14: 2k
R13: 100
R15: 7.5k
SW1: SW_Push; SPST-NO-4
SW1.25U1, SW1.25U2, SW1.25U3, SW1.25U4, SW1.25U5, SW1.25U6: MX_1.25U
SW1.75U1, SW1.75U2: MX_1.75U; MX-1.75U
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33: MX_1U; MX-1U
SW2.25U1: MX_2.25U; MX-2.25U
SW2.75U1: MX_2.75U; MX-2.75U
SW34: SW_DIP_x01
TP1, TP2: TestPoint; TestPoint_Pad_D2.0mm
TP3: B+
TP4: B-
U1: ATmega32U4-MU; QFN-44-1EP_7x7mm_P0.5mm_EP5.2x5.2mm
U2: USB6B1; SOT-23-6
U3: 74LVC2G34; SOT-23-6
U4: AMS1117-3.3; SOT-223-3_TabPin2
U5: nRF51x22-QFxx; QFN-48-1EP_6x6mm_P0.4mm_EP4.66x4.66mm
U6: TP4056
U7: FS312F
U8: MT3608
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-Assembly
Y1, Y2: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C18.1, C19.1, C20.1, C29.1, Q1.1 (G), R7.1, R9.1, U3.5 (VCC), U4.2 (VO), U5.1 (VDD), U5.12 (VDD), U5.35 (AVDD), U5.36 (AVDD)
+BATT: C34.1, D46.1 (K), D48.2 (A), R15.1; also elsewhere on the board
/ANT: ANT1.1 (SIG), C21.1, L1.1
/ANT1: C23.1, L2.1, U5.31 (ANT1)
/ANT2: L2.2, L3.1, U5.32 (ANT2)
/BAT+: C31.1, R13.2, SW34.1, TP3.1, U6.5
/BAT-: C32.2, Q3.1 (S), TP4.1, U7.6
/CONN: U5.27 (P0.19)
/CS: D43.1 (K), U1.29 (PB5)
/CS_3V: D43.2 (A), R9.2, U5.43 (P0.24)
/D+: R5.1, U1.4 (D+)
/D-: R6.1, U1.3 (D-)
/DFU_3V: U5.11 (P0.7)
/DN_PRE: U2.4 (I/O2), USB1.5 (DN2), USB1.7 (DN1)
/DP_PRE: U2.6 (I/O1), USB1.6 (DP1), USB1.8 (DP2)
/D_N: R6.2, U2.3 (I/O2)
/D_P: R5.2, U2.1 (I/O1)
/FACTORYRST: U5.22 (P0.16)
/FB: R15.2, R16.1, U8.3
/IRQ: U1.30 (PB6)
/IRQ_3V: U5.44 (P0.25)
/MISO: U1.11 (PB3), U5.41 (P0.22)
/MODE: U5.26 (P0.18)
/MOSI: U1.10 (PB2), U3.3 (2A)
/MOSI_3V: U3.4 (2Y), U5.42 (P0.23)
/RST: Q1.3 (D), R8.2, U1.1 (PE6)
/SCK: U1.9 (PB1), U3.1 (1A)
/SCK_3V: U3.6 (1Y), U5.40 (P0.21)
/SCL: U1.18 (PD0)
/SDA: U1.19 (PD1)
/SWDCLK: U5.24 (SWDCLK)
/SWDIO: Q1.2 (S), R7.2, U5.23 (SWDIO/~RST)
/UCAP: C5.1, U1.6 (UCAP)
/VB_PRE: C33.1, L4.1, SW34.2, U8.4, U8.5
/VB_SW: D46.2 (A), L4.2, U8.1
/VDD_PA: C26.1, L3.2, U5.30 (VDD_PA)
/XC1: C24.1, U5.37 (XC1), Y2.1
/XC2: C28.1, U5.38 (XC2), Y2.3
/XTAL1: C2.1, U1.17 (XTAL1), Y1.1
/XTAL2: C3.1, U1.16 (XTAL2), Y1.3
C0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), U1.25 (PD4)
C1: D5.1 (K), D6.1 (K), D7.1 (K), U1.26 (PD6)
C2: D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), U1.27 (PD7)
C3: D12.1 (K), D13.1 (K), D14.1 (K), U1.28 (PB4)
C4: D15.1 (K), D16.1 (K), D17.1 (K), D42.1 (K), U1.41 (PF0)
C5: D18.1 (K), D19.1 (K), D20.1 (K), U1.40 (PF1)
C6: D21.1 (K), D22.1 (K), D23.1 (K), U1.39 (PF4)
C7: D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), U1.38 (PF5)
C8: D28.1 (K), D29.1 (K), D30.1 (K), U1.37 (PF6)
C9: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U1.36 (PF7)
C10: D35.1 (K), D36.1 (K), D37.1 (K), U1.32 (PC7)
C11: D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), U1.31 (PC6)
GND: ANT1.2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.1, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), LED7.3 (VSS), LED8.3 (VSS), LED9.3 (VSS), LED10.3 (VSS), LED11.3 (VSS), LED12.3 (VSS), LED13.3 (VSS), LED14.3 (VSS), LED16.3 (VSS), LED17.3 (VSS), LED18.3 (VSS), LED19.3 (VSS), LED20.3 (VSS), LED21.3 (VSS), LED22.3 (VSS), LED24.3 (VSS), LED25.3 (VSS), LED26.3 (VSS), LED28.3 (VSS), LED29.3 (VSS), LED30.3 (VSS), LED31.3 (VSS), LED32.3 (VSS), LED33.3 (VSS), LED34.3 (VSS), LED36.3 (VSS), LED37.3 (VSS), LED38.3 (VSS), LED39.3 (VSS), LED40.3 (VSS), LED41.3 (VSS)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
LED_INPUT: LED1.4 (DI), U1.8 (PB0)
unnamed: C22.1, C23.2, L1.2
unnamed: C25.1, U5.29 (DEC2)
unnamed: C27.1, U5.39 (DEC1)
unnamed: C32.1, R13.1, U7.5
unnamed: D1.2 (A), SW2.2
unnamed: D2.2 (A), SW1.25U1.2
unnamed: D3.2 (A), SW1.75U1.2
unnamed: D4.2 (A), SW1.25U2.2
unnamed: D5.2 (A), SW3.2
unnamed: D6.2 (A), SW4.2
unnamed: D7.2 (A), SW5.2
unnamed: D8.2 (A), SW6.2
unnamed: D9.2 (A), SW7.2
unnamed: D10.2 (A), SW8.2
unnamed: D11.2 (A), SW1.25U3.2
unnamed: D12.2 (A), SW9.2
unnamed: D13.2 (A), SW10.2
unnamed: D14.2 (A), SW11.2
unnamed: D15.2 (A), SW12.2
unnamed: D16.2 (A), SW13.2
unnamed: D17.2 (A), SW2.75U1.2
unnamed: D18.2 (A), SW14.2
unnamed: D19.2 (A), SW15.2
unnamed: D20.2 (A), SW16.2
unnamed: D21.2 (A), SW17.2
unnamed: D22.2 (A), SW18.2
unnamed: D23.2 (A), SW19.2
unnamed: D24.2 (A), SW20.2
unnamed: D25.2 (A), SW21.2
unnamed: D26.2 (A), SW22.2
unnamed: D27.2 (A), SW2.25U1.2
unnamed: D28.2 (A), SW23.2
unnamed: D29.2 (A), SW24.2
unnamed: D30.2 (A), SW25.2
unnamed: D31.2 (A), SW26.2
unnamed: D32.2 (A), SW27.2
unnamed: D33.2 (A), SW28.2
unnamed: D34.2 (A), SW1.25U4.2
unnamed: D35.2 (A), SW29.2
unnamed: D36.2 (A), SW32.2
unnamed: D37.2 (A), SW30.2
unnamed: D38.2 (A), SW31.2
unnamed: D39.2 (A), SW1.75U2.2
unnamed: D40.2 (A), SW1.25U5.2
unnamed: D41.2 (A), SW1.25U6.2
unnamed: D42.2 (A), SW33.2
unnamed: D44.1 (K), R10.1
unnamed: D45.1 (K), R11.1
unnamed: LED1.2 (DO), LED5.4 (DI)
unnamed: LED2.2 (DO), LED6.4 (DI)
unnamed: LED2.4 (DI), LED43.2 (DO)
unnamed: LED3.4 (DI), LED44.2 (DO)
unnamed: LED4.2 (DO), LED7.4 (DI)
unnamed: LED4.4 (DI), LED45.2 (DO)
unnamed: LED5.2 (DO), LED8.4 (DI)
unnamed: LED6.2 (DO), LED9.4 (DI)
unnamed: LED10.2 (DO), LED14.4 (DI)
unnamed: LED3.2 (DO), LED10.4 (DI)
unnamed: LED11.2 (DO), LED19.4 (DI)
unnamed: LED7.2 (DO), LED11.4 (DI)
unnamed: LED12.2 (DO), LED16.4 (DI)
unnamed: LED8.2 (DO), LED12.4 (DI)
unnamed: LED13.2 (DO), LED17.4 (DI)
unnamed: LED9.2 (DO), LED13.4 (DI)
unnamed: LED14.2 (DO), LED18.4 (DI)
unnamed: LED16.2 (DO), LED20.4 (DI)
unnamed: LED17.2 (DO), LED21.4 (DI)
unnamed: LED18.2 (DO), LED22.4 (DI)
unnamed: LED19.2 (DO), LED31.4 (DI)
unnamed: LED20.2 (DO), LED24.4 (DI)
unnamed: LED21.2 (DO), LED25.4 (DI)
unnamed: LED22.2 (DO), LED26.4 (DI)
unnamed: LED24.2 (DO), LED28.4 (DI)
unnamed: LED25.2 (DO), LED29.4 (DI)
unnamed: LED26.2 (DO), LED30.4 (DI)
unnamed: LED28.2 (DO), LED32.4 (DI)
unnamed: LED29.2 (DO), LED33.4 (DI)
unnamed: LED30.2 (DO), LED34.4 (DI)
unnamed: LED31.2 (DO), LED39.4 (DI)
unnamed: LED32.2 (DO), LED36.4 (DI)
unnamed: LED33.2 (DO), LED37.4 (DI)
unnamed: LED34.2 (DO), LED38.4 (DI)
unnamed: LED36.2 (DO), LED40.4 (DI)
unnamed: LED37.2 (DO), LED44.4 (DI)
unnamed: LED38.2 (DO), LED41.4 (DI)
unnamed: LED39.2 (DO), LED42.4 (DI)
unnamed: LED40.2 (DO), LED43.4 (DI)
unnamed: LED41.2 (DO), LED45.4 (DI)
unnamed: LED42.2 (DO), LED46.4 (DI)
unnamed: Q2.2 (G), U7.3
unnamed: Q2.3 (D), Q3.3 (D)
unnamed: Q3.2 (G), U7.1
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R2.1, U1.33 (~HWB~/PE2)
unnamed: R3.2, USB1.4 (CC1)
unnamed: R4.1, USB1.10 (CC2)
unnamed: R10.2, U6.6
unnamed: R11.2, U6.7
unnamed: R12.1, U6.2
unnamed: R14.1, U7.2
R0: SW2.1, SW3.1, SW6.1, SW9.1, SW12.1, SW14.1, SW17.1, SW20.1, SW23.1, SW26.1, SW29.1, SW31.1, U1.22 (PD5)
R1: SW1.25U1.1, SW1.75U2.1, SW4.1, SW7.1, SW10.1, SW13.1, SW15.1, SW18.1, SW21.1, SW24.1, SW27.1, U1.21 (PD3)
R2: SW1.25U5.1, SW1.75U1.1, SW8.1, SW11.1, SW16.1, SW19.1, SW22.1, SW25.1, SW28.1, SW32.1, SW33.1, U1.20 (PD2)
R3: SW1.25U2.1, SW1.25U3.1, SW1.25U4.1, SW1.25U6.1, SW2.25U1.1, SW2.75U1.1, SW5.1, SW30.1, U1.12 (PB7)
VBUS: C30.1, D44.2 (A), D45.2 (A), D47.2 (A), TP1.1, U2.5 (VBUS), U6.4, U6.8, USB1.2 (VBUS), USB1.11 (VBUS)

Notes on the sheet:
MCU Decoupling
MCU

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
Board: 4 copper layers, 228.6 x 76.2 mm, 218 parts (121 on the bottom side), 152 nets.

Other parts of the board:
TP5: TestPoint; TestPoint_Pad_D2.0mm

Their connections:
+BATT: TP5.1; also elsewhere on the board

## Commit log

2019-05-02 Added Battery Sch
